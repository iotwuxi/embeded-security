# IAR project blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx; USE_HAL_DRIVER; USE_STM32F7XX_NUCLEO_144
  ICCARM.CCIncludePath2: ..\..\..\app\blink\config; ..\..\..\drivers\bsp\stm32f7xx_nucleo_144; ..\..\..\drivers\stm32f7xx_hal_driver\inc; ..\..\..\drivers\cmsis\inc; ..\..\..\drivers\cmsis\stm32f7xx\inc; ..\..\..\freertos\source; ..\..\..\freertos\source\portable\iar\arm_cm7\r0p1; ..\..\..\freertos\source\cmsis_rtos; ..\..\..\freertos\source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\app\udp-socket\inc
  OBJCOPY.OOCOutputFile: security.hex
  ILINK.IlinkOutputFile: security.out
  ILINK.IlinkIcfFile: ..\..\..\drivers\cmsis\stm32f7xx\source\iar\linker\stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group app/udp-socket/src
    ../../../app/blink/: app.c
  group drivers/bsp
    ../../../drivers/bsp/stm32f7xx_nucleo_144/: stm32f7xx_nucleo_144.c
  group drivers/cmsis
    ../../../drivers/cmsis/stm32f7xx/source/iar/: startup_stm32f767xx.s
    ../../../drivers/cmsis/stm32f7xx/source/: system_stm32f7xx.c
  group drivers/stm32f7xx_hal_driver
    ../../../drivers/stm32f7xx_hal_driver/src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_eth.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c
  group freertos
    ../../../freertos/source/: croutine.c list.c queue.c tasks.c timers.c
  group freertos/portable
    ../../../freertos/source/cmsis_rtos/: cmsis_os.c
    ../../../freertos/source/portable/memmang/: heap_4.c
    ../../../freertos/source/portable/iar/arm_cm7/r0p1/: port.c portasm.s
