# IAR project base64.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx; USE_HAL_DRIVER; USE_STM32F7XX_NUCLEO_144; MBEDTLS_CONFIG_FILE="stm32f7xx_mbedtls_config.h"
  ICCARM.CCIncludePath2: ..\..\..\app\base64\config; ..\..\..\drivers\bsp\stm32f7xx_nucleo_144; ..\..\..\drivers\stm32f7xx_hal_driver\inc; ..\..\..\drivers\cmsis\inc; ..\..\..\drivers\cmsis\stm32f7xx\inc; ..\..\..\freertos\source; ..\..\..\freertos\source\portable\iar\arm_cm7\r0p1; ..\..\..\freertos\source\cmsis_rtos; ..\..\..\freertos\source\include; ..\..\..\external\mbedtls\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\app\udp-socket\inc
  OBJCOPY.OOCOutputFile: security.hex
  ILINK.IlinkOutputFile: security.out
  ILINK.IlinkIcfFile: ..\..\..\drivers\cmsis\stm32f7xx\source\iar\linker\stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group app/base64/config
    ../../../app/base64/config/: FreeRTOSConfig.h stm32f7xx_hal_conf.h stm32f7xx_nucleo_config.h
  group app/base64/src
    ../../../app/base64/: app.c
  group drivers/bsp
    ../../../drivers/bsp/stm32f7xx_nucleo_144/: stm32f7xx_nucleo_144.c
  group drivers/cmsis
    ../../../drivers/cmsis/stm32f7xx/source/iar/: startup_stm32f767xx.s
    ../../../drivers/cmsis/stm32f7xx/source/: system_stm32f7xx.c
  group drivers/stm32f7xx_hal_driver
    ../../../drivers/stm32f7xx_hal_driver/src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_eth.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c
  group freertos
    ../../../freertos/source/: croutine.c list.c queue.c tasks.c timers.c
  group freertos/portable
    ../../../freertos/source/cmsis_rtos/: cmsis_os.c
    ../../../freertos/source/portable/memmang/: heap_4.c
    ../../../freertos/source/portable/iar/arm_cm7/r0p1/: port.c portasm.s
  group mbedtls/config
    ../../../external/mbedtls/configs/: config-ccm-psk-tls1_2.h
  group mbedtls/include
    ../../../external/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    ../../../external/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
