<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dtls-demo\dtls-demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\udp-socket\udp-socket.ewp</path>
  </project>
  <batchBuild/>
</workspace>


