# IAR project lwm2m-demo.ewp, settings and files
configuration client (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx; USE_HAL_DRIVER; USE_STM32F7XX_NUCLEO_144; LWM2M_LITTLE_ENDIAN; LWM2M_CLIENT_MODE; LWM2M_BOOTSTRAP; WITH_MBEDTLS; MBEDTLS_CONFIG_FILE="mbedtls_config.h"
  ICCARM.CCIncludePath2: ..\..\..\app\net; ..\..\..\app\lwm2m; ..\..\..\app\mbedtls_alt; ..\..\..\samples\stm32\lwm2m\client; ..\..\..\samples\stm32\lwm2m\client\config; ..\..\..\drivers\bsp\stm32f7xx_nucleo_144; ..\..\..\drivers\stm32f7xx_hal_driver\inc; ..\..\..\drivers\cmsis\inc; ..\..\..\drivers\cmsis\stm32f7xx\inc; ..\..\..\external\wakaama; ..\..\..\external\wakaama\er-coap-13; ..\..\..\external\lwip\src\include; ..\..\..\external\lwip\system; ..\..\..\external\mbedtls\include; ..\..\..\freertos\source; ..\..\..\freertos\source\portable\iar\arm_cm7\r0p1; ..\..\..\freertos\source\cmsis_rtos; ..\..\..\freertos\source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\samples\stm32\dtls-demo\config
  OBJCOPY.OOCOutputFile: security.hex
  ILINK.IlinkOutputFile: security.out
  ILINK.IlinkIcfFile: ..\..\..\drivers\cmsis\stm32f7xx\source\iar\linker\stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../../app/: main.c
  group app/lwm2m
    ../../../app/lwm2m/: commandline.c easy_tls.c object_access_control.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c test_object.c
  group app/mbedtls_alt
    ../../../app/mbedtls_alt/: entropy_alt.c timing_alt.c timing_alt.h
  group app/net
    ../../../app/net/: app_ethernet.c ethernetif.c net_sockets.c
  group doc
    ../../../: README.MD
  group drivers/bsp
    ../../../drivers/bsp/stm32f7xx_nucleo_144/: stm32f7xx_hal_msp.c stm32f7xx_it.c stm32f7xx_nucleo_144.c
  group drivers/cmsis
    ../../../drivers/cmsis/stm32f7xx/source/iar/: startup_stm32f767xx.s
    ../../../drivers/cmsis/stm32f7xx/source/: system_stm32f7xx.c
  group drivers/stm32f7xx_hal_driver
    ../../../drivers/stm32f7xx_hal_driver/src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_eth.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_timebase_tim.c stm32f7xx_hal_uart.c
  group external/lwip/api
    ../../../external/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group external/lwip/apps/httpd
    ../../../external/lwip/src/apps/httpd/: fs.c httpd.c
  group external/lwip/core
    ../../../external/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group external/lwip/core/ipv4
    ../../../external/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group external/lwip/netif
    ../../../external/lwip/src/netif/: ethernet.c
    ../../../external/lwip/system/OS/: sys_arch.c
  group external/mbedtls/library
    ../../../external/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group external/wakaama
    ../../../external/wakaama/: block1.c bootstrap.c data.c discover.c internals.h json.c liblwm2m.c liblwm2m.h lwm2m_list.c management.c memtrace.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c utils.c
  group external/wakaama/er-coap-13
    ../../../external/wakaama/er-coap-13/: er-coap-13.c er-coap-13.h
  group freertos
    ../../../freertos/source/: croutine.c list.c queue.c tasks.c timers.c
  group freertos/portable
    ../../../freertos/source/cmsis_rtos/: cmsis_os.c
    ../../../freertos/source/portable/memmang/: heap_4.c
    ../../../freertos/source/portable/iar/arm_cm7/r0p1/: port.c portasm.s
  group samples
    ../../../samples/stm32/lwm2m/client/: lwm2m_client_main.c lwm2m_connection.c lwm2m_platform.c
  group samples/config
    ../../../samples/stm32/wakaama/client/config/: FreeRTOSConfig.h lwipopts.h mbedtls_config.h stm32f7xx_hal_conf.h
