# IAR project coap-demo.ewp, settings and files
configuration client (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx; USE_HAL_DRIVER; USE_STM32F7XX_NUCLEO_144; UDP_CLIENT
  ICCARM.CCIncludePath2: ..\..\app\net; ..\..\samples\stm32\coap-demo; ..\..\samples\stm32\coap-demo\config; ..\..\drivers\bsp; ..\..\drivers\stm32f7xx_hal_driver\inc; ..\..\drivers\cmsis\inc; ..\..\drivers\cmsis\stm32f7xx\inc; ..\..\external\lwip\src\include; ..\..\external\lwip\system; ..\..\freertos\source; ..\..\freertos\source\portable\iar\arm_cm7\r0p1; ..\..\freertos\source\cmsis_rtos; ..\..\freertos\source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\samples\stm32\coap-demo\config
  OBJCOPY.OOCOutputFile: security.hex
  ILINK.IlinkOutputFile: security.out
  ILINK.IlinkIcfFile: ..\..\drivers\cmsis\stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration server (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\app\net; ..\..\samples\stm32\coap-demo; ..\..\samples\stm32\coap-demo\config; ..\..\drivers\bsp; ..\..\drivers\stm32f7xx_hal_driver\inc; ..\..\drivers\cmsis\inc; ..\..\drivers\cmsis\stm32f7xx\inc; ..\..\external\lwip\src\include; ..\..\external\lwip\src\include\posix; ..\..\external\lwip\system; ..\..\external\libcoap; ..\..\external\libcoap\include\; ..\..\external\libcoap\include\coap; ..\..\freertos\source; ..\..\freertos\source\portable\iar\arm_cm7\r0p1; ..\..\freertos\source\cmsis_rtos; ..\..\freertos\source\include
  group app
    ../../app/: main.c
  group app/net
    ../../app/net/: app_ethernet.c ethernetif.c
  group drivers/bsp
    ../../drivers/bsp/: stm32f7xx_hal_msp.c stm32f7xx_it.c stm32f7xx_nucleo_144.c
  group drivers/cmsis
    ../../drivers/cmsis/: startup_stm32f767xx.s
    ../../drivers/cmsis/stm32f7xx/source/: system_stm32f7xx.c
  group drivers/stm32f7xx_hal_driver
    ../../drivers/stm32f7xx_hal_driver/src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_eth.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_timebase_tim.c stm32f7xx_hal_uart.c
  group external/libcoap
    ../../external/libcoap/: coap_config.h
  group external/libcoap/include
    ../../external/libcoap/include/coap/: address.h async.h bits.h block.h coap.h coap_io.h coap_time.h debug.h encode.h hashkey.h libcoap.h mem.h net.h option.h pdu.h prng.h resource.h str.h subscribe.h types.h uri.h uthash.h utlist.h
  group external/libcoap/src
    ../../external/libcoap/src/: address.c async.c block.c cmem.c coap_io.c coap_io_lwip.c coap_time.c debug.c encode.c hashkey.c mem.c net.c option.c pdu.c resource.c str.c subscribe.c uri.c
  group external/lwip/api
    ../../external/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group external/lwip/apps/httpd
    ../../external/lwip/src/apps/httpd/: fs.c httpd.c
  group external/lwip/core
    ../../external/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group external/lwip/core/ipv4
    ../../external/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group external/lwip/netif
    ../../external/lwip/src/netif/: ethernet.c
    ../../external/lwip/system/OS/: sys_arch.c
  group freertos
    ../../freertos/source/: croutine.c list.c queue.c tasks.c timers.c
  group freertos/portable
    ../../freertos/source/cmsis_rtos/: cmsis_os.c
    ../../freertos/source/portable/memmang/: heap_4.c
    ../../freertos/source/portable/iar/arm_cm7/r0p1/: port.c portasm.s
  group samples
    ../../samples/stm32/coap-demo/: udp_server.c udp_server.h
  group samples/config
    ../../samples/stm32/coap-demo/config/: FreeRTOSConfig.h lwipopts.h stm32f7xx_hal_conf.h
